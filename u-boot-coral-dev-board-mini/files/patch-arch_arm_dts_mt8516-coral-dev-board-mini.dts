--- /dev/null
+++ arch/arm/dts/mt8516-coral-dev-board-mini.dts
@@ -0,0 +1,151 @@
+// SPDX-License-Identifier: GPL-2.0 OR MIT
+/*
+ * Google Coral Dev Board Mini (MediaTek MT8167S).
+ *
+ * The MT8167S is an MT8516 with graphics and video blocks added; everything
+ * U-Boot touches is the same.  Derived from mt8516-pumpkin.dts and from the
+ * mt8516-coral.dts in Google's Mendel Linux U-Boot fork.
+ */
+
+/dts-v1/;
+
+#include <config.h>
+#include "mt8516.dtsi"
+
+/ {
+	model = "Google Coral Dev Board Mini";
+
+	chosen {
+		stdout-path = &uart0;
+	};
+
+	/* 2 GiB LPDDR3 on production boards (EVT1 prototypes had 1 GiB). */
+	memory@40000000 {
+		device_type = "memory";
+		reg = <0x40000000 0x80000000>;
+	};
+
+	reserved-memory {
+		#address-cells = <2>;
+		#size-cells = <2>;
+
+		/* 128 KiB reserved for ARM Trusted Firmware (BL31) */
+		bl31_secmon_reserved: secmon@43000000 {
+			no-map;
+			reg = <0 0x43000000 0 0x20000>;
+		};
+	};
+
+	reg_1p8v: regulator-1p8v {
+		compatible = "regulator-fixed";
+		regulator-name = "fixed-1.8V";
+		regulator-min-microvolt = <1800000>;
+		regulator-max-microvolt = <1800000>;
+		regulator-boot-on;
+		regulator-always-on;
+	};
+
+	reg_3p3v: regulator-3p3v {
+		compatible = "regulator-fixed";
+		regulator-name = "fixed-3.3V";
+		regulator-min-microvolt = <3300000>;
+		regulator-max-microvolt = <3300000>;
+		regulator-boot-on;
+		regulator-always-on;
+	};
+};
+
+/*
+ * Bind the clock controllers and the console before relocation.  Upstream
+ * keeps these tags in mt8516-u-boot.dtsi, but that file is never pulled in
+ * (the automatic include looks for mediatek-u-boot.dtsi) and it refers to a
+ * label that does not exist.
+ */
+&infracfg {
+	bootph-all;
+};
+
+&topckgen {
+	bootph-all;
+};
+
+&topckgen_cg {
+	bootph-all;
+};
+
+&apmixedsys {
+	bootph-all;
+};
+
+/* 8 GiB eMMC on an 8-bit bus. */
+&mmc0 {
+	pinctrl-names = "default";
+	pinctrl-0 = <&mmc0_pins_default>;
+	bus-width = <8>;
+	max-frequency = <188000000>;
+	cap-mmc-highspeed;
+	mmc-hs200-1_8v;
+	cap-mmc-hw-reset;
+	latch-ck = <1>;
+	vmmc-supply = <&reg_3p3v>;
+	vqmmc-supply = <&reg_1p8v>;
+	non-removable;
+	status = "okay";
+};
+
+&pinctrl {
+	mmc0_pins_default: mmc0default {
+		mux {
+			function = "msdc";
+			groups =  "msdc0";
+		};
+
+		conf-cmd-data {
+			pins = "MSDC0_CMD", "MSDC0_DAT0", "MSDC0_DAT1",
+			       "MSDC0_DAT2", "MSDC0_DAT3", "MSDC0_DAT4",
+			       "MSDC0_DAT5", "MSDC0_DAT6", "MSDC0_DAT7";
+			input-enable;
+			bias-pull-up;
+		};
+
+		conf-clk {
+			pins = "MSDC0_CLK";
+			bias-pull-down;
+		};
+
+		conf-rst {
+			pins = "MSDC0_RSTB";
+			bias-pull-up;
+		};
+	};
+
+	uart0_pins: uart0 {
+		mux {
+			function = "uart";
+			groups = "uart0_0_rxd_txd";
+		};
+	};
+};
+
+/* Console, pins 8 (TX) and 10 (RX) of the 40-pin header. */
+&uart0 {
+	pinctrl-names = "default";
+	pinctrl-0 = <&uart0_pins>;
+	bootph-all;
+	status = "okay";
+};
+
+&watchdog {
+	status = "okay";
+};
+
+/* USB-C OTG port, used as a device for fastboot and USB ethernet. */
+&usb0 {
+	status = "okay";
+	dr_mode = "peripheral";
+
+	usb_con_c: connector {
+		compatible = "usb-c-connector";
+		label = "USB-C";
+	};
+};
